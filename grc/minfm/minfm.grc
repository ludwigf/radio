<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>64000</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.048e6</value></param>
</block>
<block>
<key>blks2_fm_demod_cf</key>
<param><key>id</key><value>blks2_fm_demod_cf_0</value></param>
<param><key>chan_rate</key><value>256e3</value></param>
<param><key>audio_decim</key><value>4</value></param>
<param><key>deviation</key><value>5000</value></param>
<param><key>audio_pass</key><value>3000</value></param>
<param><key>audio_stop</key><value>4000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>88.5e6</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>if_gain0</key><value>2</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>gain</key><value>8</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>150e3</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<connection><source_block_id>blks2_fm_demod_cf_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
