<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>siggen</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>400</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>400</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq3</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>400</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,1,1,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq4</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>400</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,1,1,3</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>form2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>choices</key><value>[gr.GR_SIN_WAVE,gr.GR_SQR_WAVE,gr.GR_TRI_WAVE,gr.GR_SAW_WAVE]</value></param>
<param><key>labels</key><value>["Sine", "Square", "Triangle", "Saw"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>form3</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>choices</key><value>[gr.GR_SIN_WAVE,gr.GR_SQR_WAVE,gr.GR_TRI_WAVE,gr.GR_SAW_WAVE]</value></param>
<param><key>labels</key><value>["Sine", "Square", "Triangle", "Saw"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>2,4,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>form4</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>choices</key><value>[gr.GR_SIN_WAVE,gr.GR_SQR_WAVE,gr.GR_TRI_WAVE,gr.GR_SAW_WAVE]</value></param>
<param><key>labels</key><value>["Sine", "Square", "Triangle", "Saw"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>3,4,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain3</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain4</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_histosink2</key>
<param><key>id</key><value>wxgui_histosink2_0</value></param>
<param><key>title</key><value>Histogram Plot</value></param>
<param><key>num_bins</key><value>27</value></param>
<param><key>frame_size</key><value>1000</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>notebook</key><value>notebook,2</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>notebook</key><value>notebook,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>notebook</key><value>notebook,0</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>notebook</key><value>notebook,3</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import gr</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>form1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>choices</key><value>[gr.GR_SIN_WAVE,gr.GR_SQR_WAVE,gr.GR_TRI_WAVE,gr.GR_SAW_WAVE]</value></param>
<param><key>labels</key><value>["Sine", "Square", "Triangle", "Saw"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>signal2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>form2</value></param>
<param><key>freq</key><value>freq2</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>mult2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gain2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_mute_xx</key>
<param><key>id</key><value>mute2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>m2</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>m1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>signal1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>form1</value></param>
<param><key>freq</key><value>freq1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>mult1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gain1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_mute_xx</key>
<param><key>id</key><value>mute1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>m1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>signal4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>form4</value></param>
<param><key>freq</key><value>freq4</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>mult4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gain4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>signal3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>form3</value></param>
<param><key>freq</key><value>freq3</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>mult3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gain3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_mute_xx</key>
<param><key>id</key><value>mute3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>m3</value></param>
</block>
<block>
<key>gr_mute_xx</key>
<param><key>id</key><value>mute4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>m4</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>m2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>m3</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>2,5,1,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>m4</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>3,5,1,1</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>add</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>divide</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.25</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook,4</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>["Scope","FFT", "Histo","Water","Number"]</value></param>
</block>
<connection><source_block_id>divide</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mult4</source_block_id><sink_block_id>add</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>mult3</source_block_id><sink_block_id>add</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>mult2</source_block_id><sink_block_id>add</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>wxgui_histosink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal2</source_block_id><sink_block_id>mute2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mute2</source_block_id><sink_block_id>mult2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal1</source_block_id><sink_block_id>mute1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mute1</source_block_id><sink_block_id>mult1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mult1</source_block_id><sink_block_id>add</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal4</source_block_id><sink_block_id>mute4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mute4</source_block_id><sink_block_id>mult4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal3</source_block_id><sink_block_id>mute3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mute3</source_block_id><sink_block_id>mult3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add</source_block_id><sink_block_id>divide</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
